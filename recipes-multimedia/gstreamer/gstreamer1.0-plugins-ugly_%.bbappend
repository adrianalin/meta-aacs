PACKAGECONFIG_append = " x264"